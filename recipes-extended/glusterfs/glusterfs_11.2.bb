SRCREV = "15d3c0f8435814fdb7242a8a82fa5db140013d0a"
SRC_URI = "git://github.com/gluster/glusterfs.git;branch=release-11;protocol=https"

require glusterfs.inc
